FILESEXTRAPATHS_append := ":${THISDIR}/${PN}"

SRC_URI += "file://tslib.patch"

